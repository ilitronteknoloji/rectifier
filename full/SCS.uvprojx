# Keil uVision project SCS.uvprojx, settings and files
target SCS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x8000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Test1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\MyLibrary
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: main.c todo.txt adc_drv.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
